#include "jpeg_synth.h"

#include <string.h>

static const uint8_t base_quant_luma[64] = {
    16, 11, 10, 16, 24, 40, 51, 61,
    12, 12, 14, 19, 26, 58, 60, 55,
    14, 13, 16, 24, 40, 57, 69, 56,
    14, 17, 22, 29, 51, 87, 80, 62,
    18, 22, 37, 56, 68, 109, 103, 77,
    24, 35, 55, 64, 81, 104, 113, 92,
    49, 64, 78, 87, 103, 121, 120, 101,
    72, 92, 95, 98, 112, 100, 103, 99,
};

static const uint8_t base_quant_chroma[64] = {
    17, 18, 24, 47, 99, 99, 99, 99,
    18, 21, 26, 66, 99, 99, 99, 99,
    24, 26, 56, 99, 99, 99, 99, 99,
    47, 66, 99, 99, 99, 99, 99, 99,
    99, 99, 99, 99, 99, 99, 99, 99,
    99, 99, 99, 99, 99, 99, 99, 99,
    99, 99, 99, 99, 99, 99, 99, 99,
    99, 99, 99, 99, 99, 99, 99, 99,
};

static const uint8_t hf_luma_dc_bits[16] = {
    0x00, 0x01, 0x05, 0x01, 0x01, 0x01, 0x01, 0x01,
    0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
static const uint8_t hf_luma_dc_vals[12] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
    0x08, 0x09, 0x0A, 0x0B,
};

static const uint8_t hf_chroma_dc_bits[16] = {
    0x00, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
    0x01, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
};
static const uint8_t hf_chroma_dc_vals[12] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
    0x08, 0x09, 0x0A, 0x0B,
};

static const uint8_t hf_luma_ac_bits[16] = {
    0x00, 0x02, 0x01, 0x03, 0x03, 0x02, 0x04, 0x03,
    0x05, 0x05, 0x04, 0x04, 0x00, 0x00, 0x01, 0x7D,
};
static const uint8_t hf_luma_ac_vals[162] = {
    0x01, 0x02, 0x03, 0x00, 0x04, 0x11, 0x05, 0x12,
    0x21, 0x31, 0x41, 0x06, 0x13, 0x51, 0x61, 0x07,
    0x22, 0x71, 0x14, 0x32, 0x81, 0x91, 0xA1, 0x08,
    0x23, 0x42, 0xB1, 0xC1, 0x15, 0x52, 0xD1, 0xF0,
    0x24, 0x33, 0x62, 0x72, 0x82, 0x09, 0x0A, 0x16,
    0x17, 0x18, 0x19, 0x1A, 0x25, 0x26, 0x27, 0x28,
    0x29, 0x2A, 0x34, 0x35, 0x36, 0x37, 0x38, 0x39,
    0x3A, 0x43, 0x44, 0x45, 0x46, 0x47, 0x48, 0x49,
    0x4A, 0x53, 0x54, 0x55, 0x56, 0x57, 0x58, 0x59,
    0x5A, 0x63, 0x64, 0x65, 0x66, 0x67, 0x68, 0x69,
    0x6A, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78, 0x79,
    0x7A, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88, 0x89,
    0x8A, 0x92, 0x93, 0x94, 0x95, 0x96, 0x97, 0x98,
    0x99, 0x9A, 0xA2, 0xA3, 0xA4, 0xA5, 0xA6, 0xA7,
    0xA8, 0xA9, 0xAA, 0xB2, 0xB3, 0xB4, 0xB5, 0xB6,
    0xB7, 0xB8, 0xB9, 0xBA, 0xC2, 0xC3, 0xC4, 0xC5,
    0xC6, 0xC7, 0xC8, 0xC9, 0xCA, 0xD2, 0xD3, 0xD4,
    0xD5, 0xD6, 0xD7, 0xD8, 0xD9, 0xDA, 0xE1, 0xE2,
    0xE3, 0xE4, 0xE5, 0xE6, 0xE7, 0xE8, 0xE9, 0xEA,
    0xF1, 0xF2, 0xF3, 0xF4, 0xF5, 0xF6, 0xF7, 0xF8,
    0xF9, 0xFA,
};

static const uint8_t hf_chroma_ac_bits[16] = {
    0x00, 0x02, 0x01, 0x02, 0x04, 0x04, 0x03, 0x04,
    0x07, 0x05, 0x04, 0x04, 0x00, 0x01, 0x02, 0x77,
};
static const uint8_t hf_chroma_ac_vals[162] = {
    0x00, 0x01, 0x02, 0x03, 0x11, 0x04, 0x05, 0x21,
    0x31, 0x06, 0x12, 0x41, 0x51, 0x07, 0x61, 0x71,
    0x13, 0x22, 0x32, 0x81, 0x08, 0x14, 0x42, 0x91,
    0xA1, 0xB1, 0xC1, 0x09, 0x23, 0x33, 0x52, 0xF0,
    0x15, 0x62, 0x72, 0xD1, 0x0A, 0x16, 0x24, 0x34,
    0xE1, 0x25, 0xF1, 0x17, 0x18, 0x19, 0x1A, 0x26,
    0x27, 0x28, 0x29, 0x2A, 0x35, 0x36, 0x37, 0x38,
    0x39, 0x3A, 0x43, 0x44, 0x45, 0x46, 0x47, 0x48,
    0x49, 0x4A, 0x53, 0x54, 0x55, 0x56, 0x57, 0x58,
    0x59, 0x5A, 0x63, 0x64, 0x65, 0x66, 0x67, 0x68,
    0x69, 0x6A, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78,
    0x79, 0x7A, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87,
    0x88, 0x89, 0x8A, 0x92, 0x93, 0x94, 0x95, 0x96,
    0x97, 0x98, 0x99, 0x9A, 0xA2, 0xA3, 0xA4, 0xA5,
    0xA6, 0xA7, 0xA8, 0xA9, 0xAA, 0xB2, 0xB3, 0xB4,
    0xB5, 0xB6, 0xB7, 0xB8, 0xB9, 0xBA, 0xC2, 0xC3,
    0xC4, 0xC5, 0xC6, 0xC7, 0xC8, 0xC9, 0xCA, 0xD2,
    0xD3, 0xD4, 0xD5, 0xD6, 0xD7, 0xD8, 0xD9, 0xDA,
    0xE2, 0xE3, 0xE4, 0xE5, 0xE6, 0xE7, 0xE8, 0xE9,
    0xEA, 0xF2, 0xF3, 0xF4, 0xF5, 0xF6, 0xF7, 0xF8,
    0xF9, 0xFA,
};

static uint8_t scale_quant(uint8_t base, int factor)
{
    int v = ((int)base * factor + 50) / 100;
    if (v < 1) v = 1;
    if (v > 255) v = 255;
    return (uint8_t)v;
}

void jpeg_default_quant_tables(uint8_t q, uint8_t out_luma[64], uint8_t out_chroma[64])
{
    if (q < 1) q = 1;
    if (q > 99) q = 99;
    int factor = (q < 50) ? (5000 / (int)q) : (200 - 2 * (int)q);
    for (int i = 0; i < 64; ++i) {
        out_luma[i]   = scale_quant(base_quant_luma[i],   factor);
        out_chroma[i] = scale_quant(base_quant_chroma[i], factor);
    }
}

typedef struct {
    uint8_t *buf;
    size_t off;
    size_t cap;
    bool ok;
} writer_t;

static void w_u8(writer_t *w, uint8_t v)
{
    if (!w->ok || w->off + 1 > w->cap) { w->ok = false; return; }
    w->buf[w->off++] = v;
}

static void w_u16be(writer_t *w, uint16_t v)
{
    w_u8(w, (uint8_t)((v >> 8) & 0xFF));
    w_u8(w, (uint8_t)(v & 0xFF));
}

static void w_bytes(writer_t *w, const uint8_t *src, size_t n)
{
    if (!w->ok || w->off + n > w->cap) { w->ok = false; return; }
    memcpy(w->buf + w->off, src, n);
    w->off += n;
}

static void emit_dqt(writer_t *w, uint8_t table_id, const uint8_t *values)
{
    w_u8(w, 0xFF);
    w_u8(w, 0xDB);
    w_u16be(w, 67);
    w_u8(w, table_id);
    w_bytes(w, values, 64);
}

static void emit_dht(writer_t *w, uint8_t class_id, const uint8_t *bits, const uint8_t *vals, size_t n_vals)
{
    uint16_t length = (uint16_t)(2 + 1 + 16 + n_vals);
    w_u8(w, 0xFF);
    w_u8(w, 0xC4);
    w_u16be(w, length);
    w_u8(w, class_id);
    w_bytes(w, bits, 16);
    w_bytes(w, vals, n_vals);
}

static void emit_sof0(writer_t *w, uint16_t width, uint16_t height, uint8_t type)
{
    uint8_t y_sampling = (type == 0) ? 0x21 : 0x22;
    w_u8(w, 0xFF);
    w_u8(w, 0xC0);
    w_u16be(w, 17);
    w_u8(w, 8);
    w_u16be(w, height);
    w_u16be(w, width);
    w_u8(w, 3);
    w_u8(w, 1); w_u8(w, y_sampling); w_u8(w, 0);
    w_u8(w, 2); w_u8(w, 0x11);       w_u8(w, 1);
    w_u8(w, 3); w_u8(w, 0x11);       w_u8(w, 1);
}

static void emit_sos(writer_t *w)
{
    w_u8(w, 0xFF); w_u8(w, 0xDA);
    w_u16be(w, 12);
    w_u8(w, 3);
    w_u8(w, 1); w_u8(w, 0x00);
    w_u8(w, 2); w_u8(w, 0x11);
    w_u8(w, 3); w_u8(w, 0x11);
    w_u8(w, 0x00); w_u8(w, 0x3F); w_u8(w, 0x00);
}

int jpeg_synth_build(const jpeg_synth_input_t *in, uint8_t *out, size_t out_cap)
{
    if (in->type != 0 && in->type != 1) {
        return -1;
    }

    uint8_t qt_luma[64];
    uint8_t qt_chroma[64];
    const uint8_t *luma_p;
    const uint8_t *chroma_p;
    if (in->qt_present) {
        luma_p = in->qt_luma;
        chroma_p = in->qt_chroma;
    } else {
        jpeg_default_quant_tables(in->q, qt_luma, qt_chroma);
        luma_p = qt_luma;
        chroma_p = qt_chroma;
    }

    writer_t w = { .buf = out, .off = 0, .cap = out_cap, .ok = true };

    w_u8(&w, 0xFF); w_u8(&w, 0xD8);

    emit_dqt(&w, 0, luma_p);
    emit_dqt(&w, 1, chroma_p);

    emit_sof0(&w, in->width, in->height, in->type);

    emit_dht(&w, 0x00, hf_luma_dc_bits,   hf_luma_dc_vals,   12);
    emit_dht(&w, 0x10, hf_luma_ac_bits,   hf_luma_ac_vals,   162);
    emit_dht(&w, 0x01, hf_chroma_dc_bits, hf_chroma_dc_vals, 12);
    emit_dht(&w, 0x11, hf_chroma_ac_bits, hf_chroma_ac_vals, 162);

    emit_sos(&w);

    w_bytes(&w, in->scan, in->scan_len);

    w_u8(&w, 0xFF); w_u8(&w, 0xD9);

    if (!w.ok) {
        return -1;
    }
    return (int)w.off;
}
